# Keil uVision project ldm-urob-ve1t-ping.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: ldm-urob-ve1t-ping +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group src
    ./: main.c pipistrellus.c
software components: Device:Startup 1.5, Drivers:DMA 1.5, Drivers:EEPROM 1.5, Drivers:Ethernet 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5
